# IAR project direct_test_mode_pca10040e.ewp, settings and files
configuration nrf52810_xxaa (ARM)
  General.OGChipSelectEditMenu: nRF52810_xxaa nRF52810_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10040; BSP_DEFINES_ONLY; CONFIG_GPIO_AS_PINRESET; DEVELOP_IN_NRF52832; FLOAT_ABI_SOFT; NRF52810_XXAA; NRF52_PAN_74
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\ble\ble_dtm; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\experimental_log; ..\..\..\..\..\..\components\libraries\experimental_log\src; ..\..\..\..\..\..\components\libraries\experimental_memobj; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\modules\nrfx\mdk; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: direct_test_mode_pca10040e.hex
  ILINK.IlinkOutputFile: direct_test_mode_pca10040e.out
  ILINK.IlinkIcfFile: direct_test_mode_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group nRF_Drivers
    ../../../../../../integration/nrfx/legacy/: nrf_drv_uart.c
    ../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../../../../../modules/nrfx/drivers/src/: nrfx_uarte.c
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group nRF_BLE
    ../../../../../../components/ble/ble_dtm/: ble_dtm.c ble_dtm_hw_nrf52.c
  group None
    ../../../../../../modules/nrfx/mdk/: iar_startup_nrf52810.s system_nrf52810.c
