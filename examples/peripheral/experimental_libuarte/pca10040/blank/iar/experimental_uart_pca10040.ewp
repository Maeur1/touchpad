# IAR project experimental_uart_pca10040.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10040; BSP_DEFINES_ONLY; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52; NRF52832_XXAA; NRF52_PAN_74
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\..\components\libraries\experimental_libuarte; ..\..\..\..\..\..\components\libraries\experimental_log; ..\..\..\..\..\..\components\libraries\experimental_log\src; ..\..\..\..\..\..\components\libraries\experimental_memobj; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\modules\nrfx\mdk; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: experimental_uart_pca10040.hex
  ILINK.IlinkOutputFile: experimental_uart_pca10040.out
  ILINK.IlinkIcfFile: experimental_uart_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../components/libraries/experimental_libuarte/: nrf_libuarte.c nrf_libuarte_async.c
    ../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Drivers
    ../../../../../../modules/nrfx/drivers/src/: nrfx_ppi.c nrfx_timer.c
  group None
    ../../../../../../modules/nrfx/mdk/: iar_startup_nrf52.s system_nrf52.c
